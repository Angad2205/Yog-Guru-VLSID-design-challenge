# Keil uVision project lvgl_guider_cm7.uvprojx, settings and files
target lvgl_guider_cm7 flexspi_nor_sdram_debug (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_guider_cm7.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, DEBUG, CPU_MIMXRT1176DVMAA_cm7, LV_CONF_INCLUDE_SIMPLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, VG_COMMAND_CALL=1, VG_TARGET_FAST_CLEAR=0, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: ../Core/board;../Core/source;../Core/CMSIS;../Core/component/lists;../Core/component/serial_manager;../Core/component/uart;../../custom;../Core/device;../Core/drivers;../Core/freertos/freertos-kernel/include;../Core/freertos/freertos-kernel/portable/GCC/ARM_CM4F;../../generated;../../generated/guider_customer_fonts;../../generated/guider_fonts;../Core/lvgl;../Core/lvgl/lvgl;../Core/lvgl/lvgl/src;../Core/lvgl/lvgl/src/font;../Core/touchpanel;../Core/utilities;../Core/vglite/VGLite/rtos;../Core/vglite/VGLiteKernel;../Core/vglite/VGLiteKernel/rtos;../Core/vglite/font;../Core/vglite/font/mcufont/decoder;../Core/vglite/inc;../Core/video;../Core/xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: source
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176/arm/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --predefine="-DXIP_BOOT_HEADER_DCD_ENABLE=0" --predefine="-DXIP_BOOT_HEADER_XMCD_ENABLE=1" --predefine="-D__use_flash64MB__=1"
--remove
  group board
    ../Core/board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h lvgl_support.c lvgl_support.h pin_mux.c pin_mux.h vglite_support.c vglite_support.h xmcd.c xmcd.h
  group CMSIS
    ../Core/CMSIS/: cachel1_armv7.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../Core/component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../Core/component/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../Core/component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group custom
    ../../custom/: custom.c custom.h custom.mk lv_conf_ext.h
  group device
    ../Core/device/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../Core/doc/: readme.txt
  group drivers
    ../Core/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_pmu.c fsl_pmu.h fsl_pxp.c fsl_pxp.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h
  group freertos/freertos-kernel
    ../Core/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../Core/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM4F
    ../Core/freertos/freertos-kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../Core/freertos/freertos-kernel/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable
    ../Core/freertos/freertos-kernel/portable/: readme.txt
  group generated
    ../../generated/: events_init.c events_init.h fs_driver.py generated.mk gui_guider.c gui_guider.h gui_guider.py setup_scr_about_us.c setup_scr_hastaa.c setup_scr_has_intro.c setup_scr_home_screen.c setup_scr_menuDemo.c setup_scr_padmasan.c setup_scr_padma_intro.c setup_scr_progress.c setup_scr_qr.c setup_scr_vrikshasan.c setup_scr_vriks_intro.c setup_scr_Yoga_selection.c widgets_init.c widgets_init.h
  group generated\guider_customer_fonts
    ../../generated/guider_customer_fonts/: guider_customer_fonts.h guider_customer_fonts.mk
  group generated\guider_fonts
    ../../generated/guider_fonts/: guider_fonts.h guider_fonts.mk lv_font_Alatsi_Regular_20.c lv_font_Alatsi_Regular_37.c lv_font_Alatsi_Regular_40.c lv_font_Alatsi_Regular_45.c lv_font_Alatsi_Regular_47.c lv_font_Alatsi_Regular_52.c lv_font_Alatsi_Regular_60.c lv_font_Alatsi_Regular_63.c lv_font_Alatsi_Regular_92.c lv_font_montserratMedium_16.c lv_font_montserratMedium_24.c lv_font_montserratMedium_26.c lv_font_montserratMedium_31.c lv_font_montserratMedium_33.c lv_font_montserratMedium_37.c lv_font_montserratMedium_42.c lv_font_montserratMedium_47.c lv_font_montserratMedium_49.c lv_font_montserratMedium_52.c lv_font_montserratMedium_74.c lv_font_montserratMedium_92.c
  group generated\images
    ../../generated/images/: hastaa_animimg_110.c hastaa_animimg_111.c hastaa_animimg_112.c hastaa_animimg_113.c hastaa_animimg_114.c hastaa_animimg_115.c hastaa_animimg_116.c hastaa_animimg_117.c hastaa_animimg_118.c hastaa_animimg_119.c hastaa_animimg_12.c hastaa_animimg_121.c hastaa_animimg_122.c hastaa_animimg_123.c hastaa_animimg_124.c hastaa_animimg_126.c hastaa_animimg_127.c hastaa_animimg_128.c hastaa_animimg_13.c hastaa_animimg_130.c hastaa_animimg_131.c hastaa_animimg_134.c hastaa_animimg_136.c hastaa_animimg_15.c hastaa_animimg_16.c hastaa_animimg_17.c hastaa_animimg_18.c hastaa_animimg_19.c images.mk vrikshasan_animimg_1700.c vrikshasan_animimg_1701.c vrikshasan_animimg_1702.c vrikshasan_animimg_1703.c vrikshasan_animimg_1704.c vrikshasan_animimg_1705.c vrikshasan_animimg_1706.c vrikshasan_animimg_1707.c vrikshasan_animimg_1708.c vrikshasan_animimg_1709.c vrikshasan_animimg_1710.c vrikshasan_animimg_1711.c vrikshasan_animimg_1712.c vrikshasan_animimg_1713.c vrikshasan_animimg_1714.c vrikshasan_animimg_1715.c vrikshasan_animimg_1716.c vrikshasan_animimg_1717.c vrikshasan_animimg_1718.c vrikshasan_animimg_1719.c _16_alpha_1280x721.c _400_alpha_97x65.c _401_alpha_89x74.c _403_alpha_120x74.c _405_alpha_86x57.c _406_alpha_122x86.c _406_alpha_124x97.c _406_alpha_128x100.c _407_alpha_120x93.c _407_alpha_121x99.c _407_alpha_122x88.c _407_alpha_122x92.c _408_alpha_129x76.c _410_alpha_121x74.c _42_alpha_1284x722.c _asan1_alpha_282x458.c _asan2_alpha_280x458.c _asan3_alpha_291x463.c _BABA_alpha_323x308.c _battery_alpha_530x195.c _checklist_alpha_1280x720.c _delete_74x68.c _end_call_alpha_98x95.c _intro1_alpha_1280x720.c _intro2_alpha_1280x720.c _intro3_alpha_1280x720.c _mode1_alpha_211x211.c _mode2_alpha_211x211.c _mode3_alpha_211x211.c _pad_alpha_1280x720.c _phone_card_alpha_98x95.c _QR_alpha_1280x720.c _radio_bg_800x214.c _radio_play_214x214.c _session_alpha_1280x720.c _Yog_alpha_1282x721.c
  group generated\MicroPython
    ../../generated/MicroPython/: 10_796_511.png 11_796_511.png 12_796_511.png 13_796_511.png 14_796_511.png 15_796_511.png 16_1280_721.png 16_796_511.png 17_796_511.png 18_796_511.png 19_796_511.png 21_796_511.png 22_796_511.png 23_796_511.png 24_796_511.png 26_796_511.png 27_796_511.png 28_796_511.png 2_796_511.png 30_796_511.png 31_796_511.png 34_796_511.png 36_796_511.png 3_796_511.png 400_97_65.png 401_89_74.png 403_120_74.png 405_86_57.png 406_122_86.png 406_124_97.png 406_128_100.png 407_120_93.png 407_121_99.png 407_122_88.png 407_122_92.png 408_129_76.png 410_121_74.png 42_1284_722.png 5_796_511.png 6_796_511.png 700_796_511.png 701_796_511.png 702_796_511.png 703_796_511.png 704_796_511.png 705_796_511.png 706_796_511.png 707_796_511.png 708_796_511.png 709_796_511.png 710_796_511.png 711_796_511.png 712_796_511.png 713_796_511.png 714_796_511.png 715_796_511.png 716_796_511.png 717_796_511.png 718_796_511.png 719_796_511.png 7_796_511.png 8_796_511.png 9_796_511.png asan1_282_458.png asan2_280_458.png asan3_291_463.png BABA_323_308.png battery_530_195.png checklist_1280_720.png delete_74_68.png end_call_98_95.png intro1_1280_720.png intro2_1280_720.png intro3_1280_720.png lv_font_Alatsi_Regular_20.fnt lv_font_Alatsi_Regular_37.fnt lv_font_Alatsi_Regular_40.fnt lv_font_Alatsi_Regular_45.fnt lv_font_Alatsi_Regular_47.fnt lv_font_Alatsi_Regular_52.fnt lv_font_Alatsi_Regular_60.fnt lv_font_Alatsi_Regular_63.fnt lv_font_Alatsi_Regular_92.fnt lv_font_montserratMedium_16.fnt lv_font_montserratMedium_24.fnt lv_font_montserratMedium_26.fnt lv_font_montserratMedium_31.fnt lv_font_montserratMedium_33.fnt lv_font_montserratMedium_37.fnt lv_font_montserratMedium_42.fnt lv_font_montserratMedium_47.fnt lv_font_montserratMedium_49.fnt lv_font_montserratMedium_52.fnt lv_font_montserratMedium_74.fnt lv_font_montserratMedium_92.fnt mode1_211_211.png mode2_211_211.png mode3_211_211.png pad_1280_720.png phone_card_98_95.png QR_1280_720.png radio_bg_800_214.png radio_play_214_214.png session_1280_720.png Yog_1282_721.png
  group lvgl/lvgl
    ../Core/lvgl/lvgl/: LICENCE.txt lvgl.h
  group lvgl/lvgl/src/core
    ../Core/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw/arm2d
    ../Core/lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.h
  group lvgl/lvgl/src/draw
    ../Core/lvgl/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/draw/nxp/pxp
    ../Core/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
  group lvgl/lvgl/src/draw/nxp/vglite
    ../Core/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_line.c lv_draw_vglite_line.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_vglite_buf.c lv_vglite_buf.h lv_vglite_utils.c lv_vglite_utils.h
  group lvgl/lvgl/src/draw/sdl
    ../Core/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
  group lvgl/lvgl/src/draw/stm32_dma2d
    ../Core/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/lvgl/src/draw/sw
    ../Core/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/lvgl/src/draw/swm341_dma2d
    ../Core/lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../Core/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../Core/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/layouts
    ../Core/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/libs/barcode
    ../Core/lvgl/lvgl/src/extra/libs/barcode/: code128.c code128.h lv_barcode.c lv_barcode.h
  group lvgl/lvgl/src/extra/libs/bmp
    ../Core/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/lvgl/src/extra/libs/ffmpeg
    ../Core/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/lvgl/src/extra/libs/freetype
    ../Core/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/lvgl/src/extra/libs/fsdrv
    ../Core/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_rawfs.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/lvgl/src/extra/libs/gif
    ../Core/lvgl/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/lvgl/src/extra/libs
    ../Core/lvgl/lvgl/src/extra/libs/: lv_libs.h
  group lvgl/lvgl/src/extra/libs/png
    ../Core/lvgl/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/lvgl/src/extra/libs/qrcode
    ../Core/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/lvgl/src/extra/libs/rlottie
    ../Core/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/lvgl/src/extra/libs/sjpg
    ../Core/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/lvgl/src/extra
    ../Core/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/others/fragment
    ../Core/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
  group lvgl/lvgl/src/extra/others/gridnav
    ../Core/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/lvgl/src/extra/others/ime
    ../Core/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h
  group lvgl/lvgl/src/extra/others/imgfont
    ../Core/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/lvgl/src/extra/others
    ../Core/lvgl/lvgl/src/extra/others/: lv_others.h
  group lvgl/lvgl/src/extra/others/monkey
    ../Core/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/lvgl/src/extra/others/msg
    ../Core/lvgl/lvgl/src/extra/others/msg/: lv_msg.c lv_msg.h
  group lvgl/lvgl/src/extra/others/snapshot
    ../Core/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/lvgl/src/extra/themes/basic
    ../Core/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../Core/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes
    ../Core/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/mono
    ../Core/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets/analogclock
    ../Core/lvgl/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c lv_analogclock.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../Core/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../Core/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/carousel
    ../Core/lvgl/lvgl/src/extra/widgets/carousel/: lv_carousel.c lv_carousel.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../Core/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../Core/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/dclock
    ../Core/lvgl/lvgl/src/extra/widgets/dclock/: lv_dclock.c lv_dclock.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../Core/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../Core/lvgl/lvgl/src/extra/widgets/keyboard/: chinese_library.h lv_keyboard.c lv_keyboard.h lv_zh_keyboard.c lv_zh_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../Core/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../Core/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets
    ../Core/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/menu
    ../Core/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../Core/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../Core/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/radiobtn
    ../Core/lvgl/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c lv_radiobtn.h
  group lvgl/lvgl/src/extra/widgets/span
    ../Core/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../Core/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../Core/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../Core/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/textprogress
    ../Core/lvgl/lvgl/src/extra/widgets/textprogress/: lv_textprogress.c lv_textprogress.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../Core/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/video
    ../Core/lvgl/lvgl/src/extra/widgets/video/: lv_video.c lv_video.h
  group lvgl/lvgl/src/extra/widgets/win
    ../Core/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group lvgl/lvgl/src/font
    ../Core/lvgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/lvgl/src/hal
    ../Core/lvgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src
    ../Core/lvgl/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/lvgl/src/misc
    ../Core/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/lvgl/src/widgets
    ../Core/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group lvgl/lvgl_sdk
    ../Core/lvgl/lvgl_sdk/: ChangeLogKSDK.txt
  group source
    ../Core/source/: FreeRTOSConfig.h lv_conf.h lvgl_demo_utils.c lvgl_demo_utils.h lvgl_freertos.c lvgl_freertos.h lvgl_guider.c
  group startup
    startup/: startup_MIMXRT1176_cm7.S
  group touchpanel
    ../Core/touchpanel/: fsl_gt911.c fsl_gt911.h
  group utilities
    ../Core/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group vglite
    ../Core/vglite/: ChangeLogKSDK.txt LICENSE.txt
  group vglite/font
    ../Core/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont/decoder
    ../Core/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/inc
    ../Core/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite/rtos
    ../Core/vglite/VGLite/rtos/: vg_lite_os.c vg_lite_os.h
  group vglite/VGLite
    ../Core/vglite/VGLite/: vg_lite.c vg_lite_flat.c vg_lite_flat.h vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLiteKernel/rtos
    ../Core/vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group vglite/VGLiteKernel
    ../Core/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group video
    ../Core/video/: fsl_dc_fb.h fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h fsl_display.h fsl_hx8394.c fsl_hx8394.h fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h fsl_rm68191.c fsl_rm68191.h fsl_rm68200.c fsl_rm68200.h fsl_video_common.c fsl_video_common.h
  group xip
    ../Core/xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
target lvgl_guider_cm7 flexspi_nor_sdram_release (ARM-ADS)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: lvgl_guider_cm7.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=0, XIP_BOOT_HEADER_XMCD_ENABLE=1, USE_SDRAM, DATA_SECTION_IS_CACHEABLE=1, NDEBUG, CPU_MIMXRT1176DVMAA_cm7, LV_CONF_INCLUDE_SIMPLE=1, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, VG_COMMAND_CALL=1, VG_TARGET_FAST_CLEAR=0, SERIAL_PORT_TYPE_UART=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: source
  library: MicroLIB
  memory RVCT1: ROM 0x30000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: MIMXRT1176/arm/MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.scf
  link misc: as above
